FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"
SRC_URI_append = " file://add_rescuemode_variable.patch "

